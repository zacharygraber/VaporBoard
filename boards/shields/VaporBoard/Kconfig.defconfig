## boards/shields/VaporBoard/Kconfig.defconfig
```kconfig
if SHIELD_VAPOR_BOARD

config ZMK_KEYBOARD_NAME
    default "VaporBoard v1"

endif
```
